# Keil uVision project esem16_sdk.uvproj, settings and files
target sdk (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ESEM16 ES
  cpu: IRAM(0x20000000-0x200007FF)  IROM(0x00000000-0x00008FFF) CLOCK(20000000) CPUTYPE("Cortex-M0")
  output: esem16_sdk +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c include: ..\User\inc;..\User;..\CMSIS;..\User\lib
  memory RVCT4: ROM 0x0 size 0x9000
  memory RVCT9: RAM 0x20000000 size 0x800
  group StartUp
    ./: startup_ESEM16.s
  group User
    ../User/: main.c common.c intrrupt.c task.c includes.h typedef.h macrodef.h variable.h
    ../User/src/: init.c emu.c uart.c
    ../User/inc/: uart.h
  group Doc
    ../DOC/: 说明.txt
  group lib
    ../User/lib/: esem16_flashiap.c system_esem16.c esem16_em.c esem16_scu.c esem16_gpio.c esem16_scs.c esem16_wdt.c
